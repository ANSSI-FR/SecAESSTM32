# Keil uVision project aes_m4.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: aes_m4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CC_ARM USE_KEIL_PLATFORM STATIC_TESTS_PRESENT
  c include: ..\src\tests;..\src\printf;..\src\aes;E:\generated_tests
  asm define: __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group aes
    ../src/aes/: aes.c aes.h affine_aes.h affine_aes.S compiler_abstraction.h
  group printf
    ../src/printf/: printf.c printf.h string.h
  group tests
    ../src/tests/: test.c test.h
  group main
    ../src/: main.c platform.c platform.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
